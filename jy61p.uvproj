# Keil uVision project jy61p.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32F12K54 Series STC
  cpu: IRAM(0-0x1FFF) XRAM(0x10000-0x10FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: jy61p +hex
  group Source Group 1
    ./: jy61p.c jy61p.h delay.c delay.h main.c board.c board.h
